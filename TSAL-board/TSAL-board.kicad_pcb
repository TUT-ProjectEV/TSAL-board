# Repository TUT-ProjectEV/TSAL-board

File README.md:

# "Repository name"

## Overview
- "This Repository Overview"

## Requirement
### Development
- "Development Tool Name"
### Boards
- "Platform Name, Board Name, etc..."
### Libraries
- "Library Name and Version used in this repository"

## Usage
- "How to Use, SIMPLE Explanation"

## Features
- "Detailed Description"

## Reference
- ["Reference Site Name"]("Reference URL")

## Author
- ["Your Name"]("Your GitHub, Twitter, etc... Account URL")

## License
- Copyright (c) 2023 東京工科大学 ProjectEV [Released under the MIT license]("License URL")

## KiCad design TSAL-board/TSAL-board.kicad_pcb

Parts:
C1, C10, C12: 0.1u; C_0603_1608Metric
C2, C3, C5, C6: 10u; C_1206_3216Metric
C4: 100p; C_0603_1608Metric
C7, C11: 10n; C_0603_1608Metric
C8, C9: 1u; C_0805_2012Metric
C13: 1000p; C_1206_3216Metric
D1: PZ1AH11B-AU; D_SOD-123HE_PZ1AHxxxB-AU
D2, D3: DFLZ24Q-7; D_PowerDI-123_DFLZxxQ
D4: LED; LED_0603_1608Metric
F1: 0ABB-1000-TM; Fuse_0ABB
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1, J3, J4: BM02B-PASS-1-TF; Connector_BM02B-PASS-1-TF
J2: 19427-0040; Connector_MX150L_19427-0040
Q1: DMP3098LQ-7; Package_SOT-23_DMP3098LQ-7
Q2, Q3, Q4: 2N7002K-AU; Package_SOT-23_2N7002K-AU
R1, R28, R29, R31, R35: 100k; R_0603_1608Metric
R2, R3, R4, R5, R6, R7, R8, R9: 220k; R_VishayDale_RCC1206-e3
R10: 15.4k; R_0603_1608Metric
R11: 4.3k; R_0603_1608Metric
R12, R18, R24, R25, R27: 10k; R_0603_1608Metric
R13, R14, R15, R16, R17, R19, R20, R21, R22, R23: 15k; R_TEConnectivity_3502
R26: 180k; R_0603_1608Metric
R30: 51k; R_0603_1608Metric
R32, R36, R38: 100; R_0603_1608Metric
R33: 1M; R_1206_3216Metric
R34, R40: 1M; R_0603_1608Metric
R37, R39: 0; R_0603_1608Metric
U1: TL431QDBVR; Package_SOT-23-5_TL431QDBVR
U2: TLP291(GB,SE; Isolator_TLP291(GB,SE
U3: TLC555QDRQ1; Package_SOIC-8_3.9x4.9mm_P1.27mm_TLC555QDRQ1
U4: NCV20071SN2T1G; Package_SOT-23-5_NCV20071SN2T1G

Connections:
+12V: C1.1, C2.1, C5.1, C9.2, C10.2, C12.2, D1.1 (K), Q1.2 (S), R18.1, R25.1, R27.1, R28.1, R31.1, R35.1, R37.1, R39.1, U3.8 (VDD), U4.5 (V+)
/GLV_IN: F1.1, J1.1
/RED_SIG: R31.2, R36.1, U3.3 (OUT)
/TS+: J2.1, R2.1, R6.1, R13.1, R19.1
/TS-: D2.2 (A), D3.2 (A), J2.2, R11.2, U1.5 (A)
/TSAL_GREEN_A: J3.1, R37.2
/TSAL_RED_A: J4.1, R39.2
/TS_ACTIVE: R30.2, R32.1, U3.4 (~RESET), U4.1
/~TS_ACTIVE: R27.2, U2.4 (Collector), U4.4 (-)
Earth: C13.1, H1.1, R33.1
GND: C1.2, C3.2, C6.2, C8.2, C9.1, C10.1, C11.1, C12.1, C13.2, D4.1 (K), J1.2, J1.MP1 (MountPin), J1.MP2 (MountPin), J3.MP1 (MountPin), J3.MP2 (MountPin), J4.MP1 (MountPin), J4.MP2 (MountPin), Q2.2 (S), Q3.2 (S), Q4.2 (S), R1.2, R29.2, R33.2, R34.2, R40.2, U2.3 (Emitter), U3.1 (GND), U4.2 (V-)
unnamed: C2.2, C3.1
unnamed: C5.2, C6.1
unnamed: C7.2, R12.2
unnamed: D1.2 (A), Q1.1 (G), R1.1
unnamed: C4.2, D2.1 (K), R5.2, R9.2, R10.1, R12.1, U1.4 (REF)
unnamed: D3.1 (K), R17.2, R23.2, R24.1, U2.1 (Anode)
unnamed: D4.2 (A), R18.2
unnamed: J3.2, Q3.3 (D)
unnamed: J4.2, Q4.3 (D)
unnamed: F1.2, Q1.3 (D)
unnamed: Q2.3 (D), R35.2, R38.1
unnamed: Q2.1 (G), R32.2, R34.1
unnamed: Q3.1 (G), R38.2
unnamed: Q4.1 (G), R36.2, R40.1
unnamed: R2.2, R3.1
unnamed: R3.2, R4.1
unnamed: R4.2, R5.1
unnamed: R6.2, R7.1
unnamed: R7.2, R8.1
unnamed: R8.2, R9.1
unnamed: R10.2, R11.1
unnamed: R13.2, R14.1
unnamed: R14.2, R15.1
unnamed: R15.2, R16.1
unnamed: R16.2, R17.1
unnamed: R19.2, R20.1
unnamed: R20.2, R21.1
unnamed: R21.2, R22.1
unnamed: R22.2, R23.1
unnamed: C4.1, C7.1, R24.2, U1.3 (K), U2.2 (Cathode)
unnamed: C11.2, U3.5 (CONT)
unnamed: R25.2, R26.1, U3.7 (DISCH)
unnamed: C8.1, R26.2, U3.2 (TRIG), U3.6 (THRES)
unnamed: R28.2, R29.1, R30.1, U4.3 (+)

Notes on the sheet:
350215KJT x 10 Operating Voltage 200V
点滅回路
15kOhms x10 (5025, 2W) Max 5.3mA ,0.42W (V_{TS+} - V_{TS-} = 400V) 安全係数0.25 (2W x 0.25 = 0.5W > 0.42W)
RCC1206220KFKEA x 8 Operating Voltage 200V
80V
32VDC, 1A
f = 1.44/{(R25 + 2 x R26) x C1} f = 3.89Hz Cap. Tolerance +-10% f_{Max} = 4.93Hz (including DC Bias:-11.1%) f_{Min} = 3.54Hz
100V
HIGH VOLTAGE
1kV
シュミットトリガ（反転）
GCM21BR71H105KA03L
DC BIAS Cap. Change Rate -11.1% (12V)
V_{th} = 2.495 x {(440k + R10 + R11) / (R10 + R11)} V_{th} = 58.2V sim結果 V_{th} = L -> H : 63.2V, H -> L : 47.8V (遅れ補償、シュミットトリガ分計算値からズレあり)
220kOhms x 8 (3216, 0.5W) Max 450uA, 0.045W 安全係数0.25 (0.5W x 0.25 = 0.125 > 0.045W)
Vz = 24V

Board: 2 copper layers, 82.5 x 65.0 mm, 74 parts (0 on the bottom side), 45 nets.

File TSAL-board/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C12",0603,3,0.1u,
"C11, C7",0603,2,10n,
C13,1206,1,1000p,
"C2, C3, C5, C6",1206,4,10u,
C4,0603,1,100p,
"C8, C9",0805,2,1u,
D1,D_SOD-123HE_PZ1AHxxxB-AU,1,PZ1AH11B-AU,
"D2, D3",D_PowerDI-123_DFLZxxQ,2,DFLZ24Q-7,
D4,0603,1,LED,
F1,Fuse_0ABB,1,0ABB-1000-TM,
"H1, H2, H3, H4",MountingHole_3.2mm_M3_Pad_Via,4,M3,
"J1, J3, J4",Connector_BM02B-PASS-1-TF,3,BM02B-PASS-1-TF,
J2,Connector_MX150L_19427-0040,1,19427-0040,
Q1,Package_SOT-23_DMP3098LQ-7,1,DMP3098LQ-7,
"Q2, Q3, Q4",Package_SOT-23_2N7002K-AU,3,2N7002K-AU,
"R1, R28, R29, R31, R35",0603,5,100k,
R10,0603,1,15.4k,
R11,0603,1,4.3k,
"R12, R18, R24, R25, R27",0603,5,10k,
"R13, R14, R15, R16, R17, R19, R20, R21, R22, R23",R_TEConnectivity_3502,10,15k,
"R2, R3, R4, R5, R6, R7, R8, R9",R_VishayDale_RCC1206-e3,8,220k,
R26,0603,1,180k,
R30,0603,1,51k,
"R32, R36, R38",0603,3,100,
R33,1206,1,1M,
"R34, R40",0603,2,1M,
"R37, R39",0603,2,0,
U1,Package_SOT-23-5_TL431QDBVR,1,TL431QDBVR,
U2,"Isolator_TLP291(GB,SE",1,"TLP291(GB,SE",
U3,Package_SOIC-8_3.9x4.9mm_P1.27mm_TLC555QDRQ1,1,TLC555QDRQ1,
U4,Package_SOT-23-5_NCV20071SN2T1G,1,NCV20071SN2T1G,

## Commit log

2024-04-25 Initialize main
2024-04-25 create project, add ignore folder
2024-04-25 素子追加
2024-04-25 add sim file
2024-04-26 定数修正
2024-04-27 回路追加、定数調整
2024-04-27 回路図完成
2024-04-28 定数調整
2024-04-28 コメント追加
2024-04-28 完成、未チェック
    チェック後、ガーバー出力
2024-04-29 シルク修正
2024-04-29 ガーバー、BOM出力
    JLCPCB用プラグイン使用
2024-04-30 補償回路、シュミットトリガ回路追加
2024-04-30 1ピン識別子追加
2024-04-30 ガーバー、BOM再出力
2024-05-02 sim結果追記
2024-05-02 ガーバー再出力
2024-05-23 digikey発注リスト作成
2024-05-23 購入個数追加、csv出力
2024-05-27 閾値設定用の抵抗修正
    回路図のみ、PCBやガーバーなどその他ファイルには未反映
